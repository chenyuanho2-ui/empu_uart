# Keil uVision project uart_rx.uvprojx, settings and files
target uart_rx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: uart_rx +hex
  AfterMake: fromelf --bin --output .\Objects\uart_rx.bin .\Objects\uart_rx.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\inc;..\src
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: gw1ns4c_it.c main.c
  group driver
    ../src/: gw1ns4c_uart.c
  group cmsis
    ../src/: core_cm3.c system_gw1ns4c.c startup_gw1ns4c.s
  group middleware
    ../src/: uart.c retarget.c
